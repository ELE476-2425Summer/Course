options:
  parameters:
    author: Murat Sever
    generate_options: qt_gui
    id: makingupasignal
    output_language: python
    title: Making Up A Signal
  states: {}

blocks:
- name: F0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: Fundamental Harmonic
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '100'
    stop: '2000'
    value: '1000'
  states: {}
- name: h1
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,0,1,1
    label: 1st Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h3
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,1,1,1
    label: 3rd Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h5
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,2,1,1
    label: 5th Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h7
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,3,1,1
    label: 7th Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 1*h1
    freq: 1*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: (1/3)*h3
    freq: 3*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: (1/5)*h5
    freq: 5*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: (1/7)*h7
    freq: 7*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,4
    legend: 'False'
    name: Spectrum
    showports: 'True'
    type: float
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,1,4
    label1: ''
    legend: 'False'
    name: Waveform
    size: '200'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
